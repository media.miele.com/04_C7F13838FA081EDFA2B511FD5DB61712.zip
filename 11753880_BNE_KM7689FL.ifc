Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: cf0ce5df-f06e-4094-987f-a200c0cce0f9, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-30T14:23:08+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11753880_BNE_KM7689FL:26768970_BNE_11753880_KM7689FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Glass Black, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 916 mm; Height: 51 mm; Depth: 408 mm
Pset_BuildingElementProxyCommon - Reference: 26768970_BNE_11753880_KM7689FL; sets with these values: 2
